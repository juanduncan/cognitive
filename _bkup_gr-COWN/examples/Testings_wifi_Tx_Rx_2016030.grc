<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block_waveforms</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>943e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_sin</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2.5e5</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>2.5e5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>out_buf_size</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pdu_length</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>10</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1500</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>period</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5e5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_length</value></param>
<param><key>value</key><value>320</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_size</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>COWN_tx_valve2</key>
<param><key>id</key><value>COWN_tx_valve2_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>COWN_tx_valve3</key>
<param><key>id</key><value>COWN_tx_valve3_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>delay</key><value>sync_length</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>delay</key><value>16</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/juan/cognitive/COWN/recorded_ideal_frames_20160128.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/juan/cognitive/COWN/recorded_ideal_frames_20160114_v2.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("Hola __" +"".join("x" for i in range(pdu_length)) + "1234")</value></param>
<param><key>period</key><value>period</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>5e5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>ofdm_80211_ofdm_sync_short</key>
<param><key>id</key><value>carajito</value></param>
<param><key>affinity</key><value>2</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>2**17</value></param>
<param><key>min_plateau</key><value>2</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_voltage</key><value>0.01</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(64)</value></param>
</block>
<block>
<key>ieee802_11_moving_average_xx</key>
<param><key>id</key><value>ieee802_11_moving_average_xx_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>window_size</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ieee802_11_moving_average_xx</key>
<param><key>id</key><value>ieee802_11_moving_average_xx_1</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>window_size + 16</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>ieee802_11_ofdm_decode_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_decode_mac_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>ieee802_11_ofdm_decode_signal</key>
<param><key>id</key><value>ieee802_11_ofdm_decode_signal_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>ieee802_11_ofdm_equalize_symbols</key>
<param><key>id</key><value>ieee802_11_ofdm_equalize_symbols_0</value></param>
<param><key>algo</key><value>chan_est</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>ieee802_11_ofdm_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_mac_0</value></param>
<param><key>bss_mac</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 255]</value></param>
<param><key>dst_mac</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
<param><key>src_mac</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
</block>
<block>
<key>ieee802_11_ofdm_parse_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_parse_mac_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>ieee802_11_ofdm_sync_long</key>
<param><key>id</key><value>ieee802_11_ofdm_sync_long_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>sync_length</key><value>sync_length</value></param>
</block>
<block>
<key>ieee802_11_ofdm_sync_short</key>
<param><key>id</key><value>ieee802_11_ofdm_sync_short_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>min_plateau</key><value>2</value></param>
<param><key>threshold</key><value>0.56</value></param>
</block>
<block>
<key>nutaq_carrier_perseus</key>
<param><key>id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ip_addr</key><value>192.168.0.102</value></param>
</block>
<block>
<key>ofdm_80211_short_MF_v2</key>
<param><key>id</key><value>ofdm_80211_short_MF_v2_0</value></param>
<param><key>affinity</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>2**17</value></param>
<param><key>Naver</key><value>160</value></param>
<param><key>Ndelay</key><value>16</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>avg</key><value>0.99</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>Frame error Rata</value></param>
<param><key>update_time</key><value>0.0000010</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>correlation I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>correlation Q</value></param>
<param><key>size</key><value>2**17</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>5e-3</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_tag</key><value>"encoding"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.050</value></param>
<param><key>ylabel</key><value>Received Samples</value></param>
<param><key>ymax</key><value>1000</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>style2</key><value>0</value></param>
<param><key>size</key><value>64</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.050</value></param>
<param><key>ymax</key><value>18</value></param>
<param><key>ymin</key><value>-18</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Packets Reveiced</value></param>
<param><key>size</key><value>32</value></param>
<param><key>srate</key><value>100</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Frame error rata</value></param>
<param><key>ymax</key><value>110</value></param>
</block>
<block>
<key>wifi_PHY_tx_hier</key>
<param><key>id</key><value>wifi_PHY_tx_hier_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>2**18</value></param>
<param><key>chan_est</key><value>1</value></param>
<param><key>encoding</key><value>ieee802_11.BPSK_1_2</value></param>
</block>
<connection><source_block_id>COWN_tx_valve2_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>COWN_tx_valve3_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>ieee802_11_moving_average_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>ieee802_11_ofdm_mac_0</sink_block_id><source_key>strobe</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>ieee802_11_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>carajito</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>carajito</source_block_id><sink_block_id>ieee802_11_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>ofdm_80211_short_MF_v2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>ieee802_11_ofdm_equalize_symbols_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_1</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_decode_mac_0</source_block_id><sink_block_id>ieee802_11_ofdm_parse_mac_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_decode_signal_0</source_block_id><sink_block_id>ieee802_11_ofdm_decode_mac_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_equalize_symbols_0</source_block_id><sink_block_id>ieee802_11_ofdm_decode_signal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_mac_0</source_block_id><sink_block_id>wifi_PHY_tx_hier_1</sink_block_id><source_key>phy out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_parse_mac_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>fer</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_long_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_short_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_short_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_short_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_80211_short_MF_v2_0</source_block_id><sink_block_id>carajito</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_80211_short_MF_v2_0</source_block_id><sink_block_id>carajito</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_80211_short_MF_v2_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_80211_short_MF_v2_0</source_block_id><sink_block_id>carajito</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_PHY_tx_hier_1</source_block_id><sink_block_id>COWN_tx_valve2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
