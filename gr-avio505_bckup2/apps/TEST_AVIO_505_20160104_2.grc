<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>executable_multisma</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>Executable MultiSDA </value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Radio1_chooser</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label0</key><value>Constante</value></param>
<param><key>label1</key><value>ADS-B</value></param>
<param><key>label2</key><value>DME1</value></param>
<param><key>label3</key><value>DME2</value></param>
<param><key>label</key><value>Radio1</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Radio2_chooser</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>label0</key><value>Constante</value></param>
<param><key>label1</key><value>ADS-B</value></param>
<param><key>label2</key><value>DME1</value></param>
<param><key>label3</key><value>DME2</value></param>
<param><key>label</key><value>Radio2</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq_VOR_DME1</value></param>
<param><key>value</key><value>108.00</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>DME 1, VOR frequency (MHz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq_VOR_DME2</value></param>
<param><key>value</key><value>108.5</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
<param><key>label</key><value>DME 2, VOR frequency (MHz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frq_ADSB</value></param>
<param><key>value</key><value>1e5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-250e3</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>250e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frq_DME_1</value></param>
<param><key>value</key><value>1e5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-250e3</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>250e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frq_DME_2</value></param>
<param><key>value</key><value>1e5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-250e3</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>250e3</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>reg28</value></param>
<param><key>value</key><value>5</value></param>
<param><key>label</key><value>REG28[3:0]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1.28e6</value></param>
</block>
<block>
<key>avio505_controller</key>
<param><key>id</key><value>AVIO505_controller</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>radio1_rx</key><value>nutaq_radio420_rx_1</value></param>
<param><key>radio1_tx</key><value>nutaq_radio420_tx_1</value></param>
<param><key>radio2_rx</key><value>nutaq_radio420_rx_2</value></param>
<param><key>radio2_tx</key><value>nutaq_radio420_tx_2</value></param>
<param><key>radio_sw</key><value>nutaq_custom_register_28</value></param>
<param><key>system_radio1</key><value>Radio1_chooser</value></param>
<param><key>system_radio2</key><value>Radio2_chooser</value></param>
<param><key>vor_freq_dme1</key><value>freq_VOR_DME1</value></param>
<param><key>vor_freq_dme2</key><value>freq_VOR_DME2</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>amp</key><value>0.5</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>freq</key><value>frq_DME_1</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate/20</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_0</value></param>
<param><key>amp</key><value>0.5</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>frq_DME_2</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate/20</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_0_0</value></param>
<param><key>amp</key><value>0.5</value></param>
<param><key>affinity</key><value>6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>frq_ADSB</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate/5</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>avio505_resta</key>
<param><key>id</key><value>avio505_resta_0</value></param>
<param><key>affinity</key><value>4</value></param>
</block>
<block>
<key>avio505_syncher</key>
<param><key>id</key><value>avio505_syncher_0</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>maxoutbuf</key><value>2**15</value></param>
<param><key>minoutbuf</key><value>2**15</value></param>
</block>
<block>
<key>avio505_three_ch_mux_rtdex_v2</key>
<param><key>id</key><value>avio505_three_ch_mux_rtdex_v2_1</value></param>
<param><key>affinity</key><value>5,6</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_streams</key><value>7</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_streams</key><value>4</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_1</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>maxoutbuf</key><value>2**14</value></param>
<param><key>minoutbuf</key><value>2**14</value></param>
<param><key>vector_input</key><value>True</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_1_0</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>maxoutbuf</key><value>2**14</value></param>
<param><key>minoutbuf</key><value>2**14</value></param>
<param><key>vector_input</key><value>True</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_1_1</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>maxoutbuf</key><value>2**14</value></param>
<param><key>minoutbuf</key><value>2**14</value></param>
<param><key>vector_input</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>nutaq_carrier_perseus</key>
<param><key>id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>ip_addr</key><value>192.168.0.101</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0</value></param>
<param><key>block_priority</key><value>0</value></param>
<param><key>index</key><value>1</value></param>
<param><key>value</key><value>6</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>4</value></param>
<param><key>value</key><value>6</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>20</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>30</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>31</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_1</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>19</value></param>
<param><key>value</key><value>1000000</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_2</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>18</value></param>
<param><key>value</key><value>1</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_3</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>16</value></param>
<param><key>value</key><value>2500000</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1</value></param>
<param><key>block_priority</key><value>6</value></param>
<param><key>index</key><value>0</value></param>
<param><key>value</key><value>int((2e5)/samp_rate*(2**32))</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1_0</value></param>
<param><key>block_priority</key><value>6</value></param>
<param><key>index</key><value>2</value></param>
<param><key>value</key><value>int((7.5e4)/samp_rate*(2**32))</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_28</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>28</value></param>
<param><key>value</key><value>(Radio1_chooser*4+Radio2_chooser)*16 + reg28</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_1</value></param>
<param><key>calibrate</key><value>1</value></param>
<param><key>band</key><value>0</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>rx_lna_gain</key><value>3</value></param>
<param><key>rx_lpf_bandwidth</key><value>1</value></param>
<param><key>rx_vga1_gain</key><value>1</value></param>
<param><key>rx_freq</key><value>1.041e9</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>18</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_2</value></param>
<param><key>calibrate</key><value>1</value></param>
<param><key>band</key><value>1</value></param>
<param><key>block_priority</key><value>3</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>rx_lna_gain</key><value>3</value></param>
<param><key>rx_lpf_bandwidth</key><value>1</value></param>
<param><key>rx_vga1_gain</key><value>1</value></param>
<param><key>rx_freq</key><value>2500e6</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>18</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_1</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>block_priority</key><value>0</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>tx_lpf_bandwidth</key><value>0</value></param>
<param><key>tx_vga1_gain</key><value>-4</value></param>
<param><key>tx_vga2_gain</key><value>10</value></param>
<param><key>tx_freq</key><value>541e6</value></param>
<param><key>tx_gain3</key><value>0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>1</value></param>
<param><key>block_priority</key><value>2</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>tx_lpf_bandwidth</key><value>0</value></param>
<param><key>tx_vga1_gain</key><value>-4</value></param>
<param><key>tx_vga2_gain</key><value>10</value></param>
<param><key>tx_freq</key><value>2000e6</value></param>
<param><key>tx_gain3</key><value>0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_rtdex_sink</key>
<param><key>id</key><value>nutaq_rtdex_sink_0_0</value></param>
<param><key>block_priority</key><value>8</value></param>
<param><key>channels</key><value>0</value></param>
<param><key>affinity</key><value>5</value></param>
<param><key>type</key><value>int</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>packet_size</key><value>8192</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_0_0_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>channels</key><value>0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>maxoutbuf</key><value>2**15</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>minoutbuf</key><value>2**15</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>packet_size</key><value>8192</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/5</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>affinity</key><value>7</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>2**14</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.5</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>1.1</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate/5</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>affinity</key><value>7</value></param>
<param><key>gui_hint</key><value>5,1,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>QT GUI Plot hola</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>affinity</key><value>7</value></param>
<param><key>gui_hint</key><value>5,2,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>tr_slope</key><value>qtgui.TRIG_SLOPE_NEG</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>20</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>avio505_three_ch_mux_rtdex_v2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_0</source_block_id><sink_block_id>avio505_three_ch_mux_rtdex_v2_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_0_0</source_block_id><sink_block_id>avio505_three_ch_mux_rtdex_v2_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>avio505_resta_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>avio505_syncher_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>avio505_three_ch_mux_rtdex_v2_1</source_block_id><sink_block_id>nutaq_rtdex_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_1_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>3</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>4</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>5</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>avio505_resta_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_1</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_1_1</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>avio505_three_ch_mux_rtdex_v2_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_null_source_1</source_block_id><sink_block_id>avio505_three_ch_mux_rtdex_v2_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>nutaq_custom_register_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0_0_0</source_block_id><sink_block_id>avio505_syncher_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
