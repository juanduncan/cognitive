<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wifi_tx_rx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>encoding</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label0</key><value>"BPSK 1/2"  </value></param>
<param><key>label1</key><value>"BPSK 3/4"</value></param>
<param><key>label2</key><value>"QPSK 1/2"</value></param>
<param><key>label</key><value>Encoding</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>943e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_sin</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2.5e5</value></param>
<param><key>step</key><value>500</value></param>
<param><key>stop</key><value>2.5e5</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq_sin</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>5000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>freq_sin</value></param>
<param><key>max</key><value>250e3</value></param>
<param><key>min</key><value>-250e3</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_formatter</value></param>
<param><key>value</key><value>ieee802_11.wifi_signal_field()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>out_buf_size</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pdu_length</value></param>
<param><key>value</key><value>30</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>10</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1500</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>period</value></param>
<param><key>value</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5e5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_length</value></param>
<param><key>value</key><value>320</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_size</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>COWN_resta</key>
<param><key>id</key><value>COWN_resta_0</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>COWN_syncher2</key>
<param><key>id</key><value>COWN_syncher2_0</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>COWN_tag_generator</key>
<param><key>id</key><value>COWN_tag_generator_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>0.2</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>freq_sin</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>minoutbuf</key><value>2**14</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>affinity</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>minoutbuf</key><value>2**15</value></param>
<param><key>num_streams</key><value>4</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>delay</key><value>sync_length</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>delay</key><value>16</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1_1</value></param>
<param><key>file</key><value>/home/juan/cognitive/COWN/recorded_ideal_frames_20160114_v2.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/juan/cognitive/COWN/recorded_ideal_frames_20160128.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>affinity</key><value>2</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>msg</key><value>pmt.intern("".join("x" for i in range(pdu_length)) + "1234")</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>period</key><value>period</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>ninputs</key><value>2</value></param>
<param><key>tag_preserve_head_pos</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>5e5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ofdm_80211_ofdm_sync_short</key>
<param><key>id</key><value>carajito</value></param>
<param><key>affinity</key><value>2</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>2**17</value></param>
<param><key>min_plateau</key><value>2</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>[-1, 1]</value></param>
</block>
<block>
<key>digital_ofdm_carrier_allocator_cvc</key>
<param><key>id</key><value>digital_ofdm_carrier_allocator_cvc_0_0_0</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>occupied_carriers</key><value>(range(-26, -21) + range(-20, -7) + range(-6, 0) + range(1, 7) + range(8, 21) + range(22, 27),)</value></param>
<param><key>pilot_carriers</key><value>((-21, -7, 7, 21), )</value></param>
<param><key>pilot_symbols</key><value>((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))</value></param>
<param><key>sync_words</key><value>((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), (0, 0j, 0, 0j, 0, 0j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, (-0-1j), 1, -1j, -1, 1j, 0, -1j, 1, (-0-1j), 1, -1j, 1, 1j, -1, -1j, 1, (-0-1j), -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 0j, 0, 0j, 0, 0j), (0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0))</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>input_size</key><value>64</value></param>
<param><key>tagname</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>rolloff</key><value>2</value></param>
</block>
<block>
<key>digital_packet_headergenerator_bb</key>
<param><key>id</key><value>digital_packet_headergenerator_bb_0</value></param>
<param><key>header_formatter</key><value>header_formatter.formatter()</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(64)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>tuple([1/52**.5] * 64)</value></param>
</block>
<block>
<key>foo_packet_pad2</key>
<param><key>id</key><value>foo_packet_pad2_0_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.0001</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>minoutbuf</key><value>2**18</value></param>
<param><key>pad_front</key><value>100000</value></param>
<param><key>pad_tail</key><value>100000</value></param>
</block>
<block>
<key>ieee802_11_chunks_to_symbols_xx</key>
<param><key>id</key><value>ieee802_11_chunks_to_symbols_xx_0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>ieee802_11_moving_average_xx</key>
<param><key>id</key><value>ieee802_11_moving_average_xx_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>length</key><value>window_size</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ieee802_11_moving_average_xx</key>
<param><key>id</key><value>ieee802_11_moving_average_xx_1</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>length</key><value>window_size + 16</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>ieee802_11_ofdm_decode_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_decode_mac_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>ieee802_11_ofdm_decode_signal</key>
<param><key>id</key><value>ieee802_11_ofdm_decode_signal_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>ieee802_11_ofdm_equalize_symbols</key>
<param><key>id</key><value>ieee802_11_ofdm_equalize_symbols_0</value></param>
<param><key>algo</key><value>chan_est</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>ieee802_11_ofdm_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_mac_0</value></param>
<param><key>bss_mac</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 255]</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>dst_mac</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>src_mac</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
</block>
<block>
<key>ieee802_11_ofdm_mapper</key>
<param><key>id</key><value>ieee802_11_ofdm_mapper_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>encoding</key><value>encoding</value></param>
</block>
<block>
<key>ieee802_11_ofdm_parse_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_parse_mac_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>ieee802_11_ofdm_sync_long</key>
<param><key>id</key><value>ieee802_11_ofdm_sync_long_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>sync_length</key><value>sync_length</value></param>
</block>
<block>
<key>ieee802_11_ofdm_sync_short</key>
<param><key>id</key><value>ieee802_11_ofdm_sync_short_0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>min_plateau</key><value>2</value></param>
<param><key>threshold</key><value>0.56</value></param>
</block>
<block>
<key>nutaq_carrier_perseus</key>
<param><key>id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>ip_addr</key><value>192.168.0.101</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0</value></param>
<param><key>block_priority</key><value>4</value></param>
<param><key>index</key><value>1</value></param>
<param><key>value</key><value>3</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0</value></param>
<param><key>block_priority</key><value>5</value></param>
<param><key>index</key><value>4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0</value></param>
<param><key>block_priority</key><value>5</value></param>
<param><key>index</key><value>6</value></param>
<param><key>value</key><value>600</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_1</value></param>
<param><key>block_priority</key><value>5</value></param>
<param><key>index</key><value>3</value></param>
<param><key>value</key><value>7</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1</value></param>
<param><key>block_priority</key><value>4</value></param>
<param><key>index</key><value>2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_2</value></param>
<param><key>block_priority</key><value>4</value></param>
<param><key>index</key><value>0</value></param>
<param><key>value</key><value>int((4e6)/samp_rate/40*(2**32))</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>datarate</key><value>samp_rate*2*decimation</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>rx_lna_gain</key><value>3</value></param>
<param><key>rx_lpf_bandwidth</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>3</value></param>
<param><key>rx_freq</key><value>943e6</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>3</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0_0</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>block_priority</key><value>3</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>datarate</key><value>samp_rate*2*decimation</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>rx_lna_gain</key><value>3</value></param>
<param><key>rx_lpf_bandwidth</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>1</value></param>
<param><key>rx_freq</key><value>943e6</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>8</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0_0</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>block_priority</key><value>0</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>datarate</key><value>samp_rate*2*decimation</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>tx_lpf_bandwidth</key><value>2</value></param>
<param><key>tx_vga1_gain</key><value>-15</value></param>
<param><key>tx_vga2_gain</key><value>5</value></param>
<param><key>tx_freq</key><value>943e6</value></param>
<param><key>tx_gain3</key><value>0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0_0_0</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>block_priority</key><value>2</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>datarate</key><value>samp_rate*2*decimation</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>tx_lpf_bandwidth</key><value>2</value></param>
<param><key>tx_vga1_gain</key><value>-10</value></param>
<param><key>tx_vga2_gain</key><value>15</value></param>
<param><key>tx_freq</key><value>943e6</value></param>
<param><key>tx_gain3</key><value>3</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_rtdex_sink</key>
<param><key>id</key><value>nutaq_rtdex_sink_0</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>channels</key><value>0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>packet_size</key><value>8192</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_0</value></param>
<param><key>block_priority</key><value>0</value></param>
<param><key>channels</key><value>0</value></param>
<param><key>affinity</key><value>1</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>packet_size</key><value>8192</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
</block>
<block>
<key>ofdm_80211_short_MF_v2</key>
<param><key>id</key><value>ofdm_80211_short_MF_v2_0</value></param>
<param><key>affinity</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>2**17</value></param>
<param><key>Naver</key><value>160</value></param>
<param><key>Ndelay</key><value>16</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>avg</key><value>0.99</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>Frame error Rata</value></param>
<param><key>update_time</key><value>0.0000010</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>correlation I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>correlation Q</value></param>
<param><key>size</key><value>2**16</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>5e-3</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_tag</key><value>"FISTOR"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ylabel</key><value>Output with TAG</value></param>
<param><key>ymax</key><value>1000</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>correlation I</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>correlation Q</value></param>
<param><key>size</key><value>2**10</value></param>
<param><key>srate</key><value>samp_rate/1000</value></param>
<param><key>tr_delay</key><value>5e-3</value></param>
<param><key>tr_level</key><value>0.001</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_tag</key><value>"FISTOR"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>ylabel</key><value>Generated Samples</value></param>
<param><key>ymax</key><value>1000</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>affinity</key><value>4</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>correlation I</value></param>
<param><key>size</key><value>2**14</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_delay</key><value>5e-3</value></param>
<param><key>tr_level</key><value>0.001</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_tag</key><value>"FISTOR"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>2</value></param>
<param><key>ylabel</key><value>SI soy yo</value></param>
<param><key>ymax</key><value>1000</value></param>
<param><key>ymin</key><value>-0.1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Packets Reveiced</value></param>
<param><key>size</key><value>32</value></param>
<param><key>srate</key><value>100</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Frame error rata</value></param>
<param><key>ymax</key><value>110</value></param>
</block>
<connection><source_block_id>COWN_resta_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>COWN_syncher2_0</source_block_id><sink_block_id>COWN_tag_generator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>COWN_syncher2_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_short_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_short_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>ieee802_11_moving_average_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>COWN_resta_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>ofdm_80211_short_MF_v2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>nutaq_rtdex_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>ieee802_11_ofdm_mac_0</sink_block_id><source_key>strobe</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>ieee802_11_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>digital_ofdm_carrier_allocator_cvc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>ofdm_80211_short_MF_v2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>carajito</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>carajito</source_block_id><sink_block_id>ieee802_11_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_carrier_allocator_cvc_0_0_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0_0</source_block_id><sink_block_id>foo_packet_pad2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_packet_headergenerator_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>ieee802_11_ofdm_equalize_symbols_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_1</source_block_id><sink_block_id>blocks_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_decode_mac_0</source_block_id><sink_block_id>ieee802_11_ofdm_parse_mac_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_decode_signal_0</source_block_id><sink_block_id>ieee802_11_ofdm_decode_mac_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_equalize_symbols_0</source_block_id><sink_block_id>ieee802_11_ofdm_decode_signal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_mac_0</source_block_id><sink_block_id>ieee802_11_ofdm_mapper_0</sink_block_id><source_key>phy out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_mapper_0</source_block_id><sink_block_id>digital_packet_headergenerator_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_mapper_0</source_block_id><sink_block_id>ieee802_11_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_parse_mac_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>fer</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_long_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_short_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_short_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_sync_short_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0</source_block_id><sink_block_id>COWN_syncher2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_80211_short_MF_v2_0</source_block_id><sink_block_id>carajito</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ofdm_80211_short_MF_v2_0</source_block_id><sink_block_id>carajito</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ofdm_80211_short_MF_v2_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_80211_short_MF_v2_0</source_block_id><sink_block_id>carajito</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
