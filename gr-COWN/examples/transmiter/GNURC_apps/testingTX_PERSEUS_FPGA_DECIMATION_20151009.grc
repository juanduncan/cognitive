<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wifi_tx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RF_freq</value></param>
<param><key>value</key><value>943e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RF_freq_0</value></param>
<param><key>value</key><value>943e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>value</key><value>0.125</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>encoding</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label0</key><value>"BPSK 1/2"  </value></param>
<param><key>label1</key><value>"BPSK 3/4"</value></param>
<param><key>label2</key><value>"QPSK 1/2"</value></param>
<param><key>label</key><value>Encoding</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_cos</value></param>
<param><key>value</key><value>50000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-250000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>250000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mult</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>mult_gaussian</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>out_buf_size</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_size</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>period</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10000</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500000</value></param>
<param><key>label0</key><value>'500KHz'</value></param>
<param><key>label1</key><value>'1MHz'</value></param>
<param><key>label2</key><value>'2MHz'</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>500000</value></param>
<param><key>option1</key><value>1000000</value></param>
<param><key>option2</key><value>2000000</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>0.1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>05754214</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>freq_cos</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>maxoutbuf</key><value> 0</value></param>
<param><key>minoutbuf</key><value> 0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/juan/Desktop/80211_ofdm_padded_waveform_direct_fromTX_20150930.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/juan/Desktop/waveforms/80211_ofdm_padded_waveform_direct_fromTX_20150930.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0_0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("Hello BBBBBBBBBBBB1234")</value></param>
<param><key>period</key><value>period</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("Hello BBBBBBBBBBBB1234")</value></param>
<param><key>period</key><value>period</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>mult</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>100000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>mult_gaussian/100*0.000001</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0</value></param>
<param><key>istunflag</key><value>False</value></param>
<param><key>ifn</key><value>tap0</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>blocks_tuntap_pdu</key>
<param><key>id</key><value>blocks_tuntap_pdu_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>istunflag</key><value>True</value></param>
<param><key>ifn</key><value>tap0</value></param>
<param><key>mtu</key><value>440</value></param>
</block>
<block>
<key>foo_packet_pad2</key>
<param><key>id</key><value>foo_packet_pad2_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay_sec</key><value>0.01</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
<param><key>pad_front</key><value>50</value></param>
<param><key>pad_tail</key><value>0</value></param>
</block>
<block>
<key>ieee802_11_ether_encap</key>
<param><key>id</key><value>ieee802_11_ether_encap_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_ofdm_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_mac_0</value></param>
<param><key>bss_mac</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 255]</value></param>
<param><key>dst_mac</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
<param><key>src_mac</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
</block>
<block>
<key>misc2_misc2</key>
<param><key>id</key><value>misc2_misc2_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>misc2_mysource</key>
<param><key>id</key><value>misc2_mysource_0</value></param>
<param><key>maxoutbuf</key><value>out_buf_size</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>nutaq_carrier_perseus</key>
<param><key>id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>ip_addr</key><value>192.168.0.103</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>index</key><value>1</value></param>
<param><key>value</key><value>3</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>update_rate</key><value>0.01</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0</value></param>
<param><key>block_priority</key><value>5</value></param>
<param><key>index</key><value>4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0</value></param>
<param><key>block_priority</key><value>8</value></param>
<param><key>index</key><value>3</value></param>
<param><key>value</key><value>7</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1</value></param>
<param><key>block_priority</key><value>36</value></param>
<param><key>index</key><value>0</value></param>
<param><key>value</key><value>int((4e6)/samp_rate/40*(2**32))</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>2</value></param>
<param><key>value</key><value>int(0e6/samp_rate/40*(2**32))</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1_1</value></param>
<param><key>block_priority</key><value>9</value></param>
<param><key>index</key><value>6</value></param>
<param><key>value</key><value>800</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>block_priority</key><value>2</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>datarate</key><value>samp_rate*2*decimation</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>rx_lna_gain</key><value>2</value></param>
<param><key>rx_lpf_bandwidth</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>2</value></param>
<param><key>rx_freq</key><value>RF_freq</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>-8</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0_0</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>block_priority</key><value>3</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>datarate</key><value>samp_rate*2*decimation</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>rx_lna_gain</key><value>2</value></param>
<param><key>rx_lpf_bandwidth</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>2</value></param>
<param><key>rx_freq</key><value>RF_freq</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>-8</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>block_priority</key><value>0</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>datarate</key><value>samp_rate*2*decimation</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>tx_lpf_bandwidth</key><value>2</value></param>
<param><key>tx_vga1_gain</key><value>-5</value></param>
<param><key>tx_vga2_gain</key><value>25</value></param>
<param><key>tx_freq</key><value>RF_freq</value></param>
<param><key>tx_gain3</key><value>10</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0_0</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>1</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>datarate</key><value>samp_rate*2*decimation</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>tx_lpf_bandwidth</key><value>2</value></param>
<param><key>tx_vga1_gain</key><value>-10</value></param>
<param><key>tx_vga2_gain</key><value>15</value></param>
<param><key>tx_freq</key><value>RF_freq</value></param>
<param><key>tx_gain3</key><value>3</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_rtdex_sink</key>
<param><key>id</key><value>nutaq_rtdex_sink_0</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>channels</key><value>1</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>packet_size</key><value>packet_size</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024*4</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.05</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>wifi_PHY_tx_hier</key>
<param><key>id</key><value>wifi_PHY_tx_hier_1</value></param>
<param><key>chan_est</key><value>1</value></param>
<param><key>encoding</key><value>ieee802_11.BPSK_1_2</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>misc2_misc2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>misc2_mysource_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_short_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_short_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>nutaq_rtdex_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>foo_packet_pad2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>misc2_mysource_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tuntap_pdu_0_0</source_block_id><sink_block_id>ieee802_11_ether_encap_0</sink_block_id><source_key>pdus</source_key><sink_key>from tap</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>misc2_misc2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ether_encap_0</source_block_id><sink_block_id>blocks_tuntap_pdu_0_0</sink_block_id><source_key>to tap</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_11_ether_encap_0</source_block_id><sink_block_id>ieee802_11_ofdm_mac_0</sink_block_id><source_key>to wifi</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_mac_0</source_block_id><sink_block_id>wifi_PHY_tx_hier_1</sink_block_id><source_key>phy out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>misc2_misc2_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>misc2_mysource_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_PHY_tx_hier_1</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_PHY_tx_hier_1</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
