<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>perseus_s_sensing</value></param>
<param><key>title</key><value>Perseus Spectrum Sensing</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>value</key><value>0.125</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfft</value></param>
<param><key>value</key><value>2**15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_size</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RF_freq</value></param>
<param><key>value</key><value>943e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversampling</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PSD_averaging</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>ENABLE_TX1_variable_check_box</value></param>
<param><key>label</key><value>Enable Transmission</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>True</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>show_test_statistics</value></param>
<param><key>label</key><value>Show Test Statistics (ReL and Rs)</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cosenito</value></param>
<param><key>label</key><value>cosenito</value></param>
<param><key>value</key><value>20e3</value></param>
<param><key>start</key><value>-250e3</value></param>
<param><key>stop</key><value>250e3</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>2*4e3 + 0*samp_rate/40/(oversampling*8*2)</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/juan/Music/de_mi.mp3</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>ipaddr</key><value>192.168.0.122</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>label</key><value>freq_offset</value></param>
<param><key>value</key><value>3</value></param>
<param><key>start</key><value>-1e7</value></param>
<param><key>stop</key><value>1e7</value></param>
<param><key>step</key><value>1e4</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>bits_per_symbol</key><value>8</value></param>
<param><key>preamble</key><value></value></param>
<param><key>access_code</key><value></value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>128</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>8E3</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
