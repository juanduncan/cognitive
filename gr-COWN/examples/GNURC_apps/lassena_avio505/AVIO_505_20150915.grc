<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>perseus_mimo</value></param>
<param><key>title</key><value>Perseus MIMO</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Nsamples_Qtime</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>min</key><value>-samp_rate/2</value></param>
<param><key>max</key><value>samp_rate/2</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>500e3</value></param>
<param><key>min</key><value>-samp_rate/2</value></param>
<param><key>max</key><value>samp_rate/2</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>nutaq_carrier_perseus</key>
<param><key>id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>ip_addr</key><value>192.168.0.175</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>31</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_1</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>19</value></param>
<param><key>value</key><value>1000000</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_2</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>18</value></param>
<param><key>value</key><value>1</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_3</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>16</value></param>
<param><key>value</key><value>2500000</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>6</value></param>
<param><key>index</key><value>2</value></param>
<param><key>value</key><value>int((7.5e4)/samp_rate*(2**32))</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>6</value></param>
<param><key>index</key><value>0</value></param>
<param><key>value</key><value>int((2e5)/samp_rate*(2**32))</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>0</value></param>
<param><key>index</key><value>1</value></param>
<param><key>value</key><value>6</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq1</value></param>
<param><key>value</key><value>samp_rate/20/50</value></param>
<param><key>start</key><value>-samp_rate/20/2</value></param>
<param><key>stop</key><value>samp_rate/20/2</value></param>
<param><key>step</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>3,1,3,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq2</value></param>
<param><key>value</key><value>samp_rate/20/2/20</value></param>
<param><key>start</key><value>-samp_rate/20/2</value></param>
<param><key>stop</key><value>samp_rate/20/2</value></param>
<param><key>step</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>3,3,3,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq3</value></param>
<param><key>value</key><value>samp_rate/2/5/25</value></param>
<param><key>start</key><value>-samp_rate/2/5</value></param>
<param><key>stop</key><value>samp_rate/2/5</value></param>
<param><key>step</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>30</value></param>
<param><key>value</key><value>10000</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>avio505_three_ch_multip_rtdex</key>
<param><key>id</key><value>avio505_three_ch_multip_rtdex_0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate/5</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>freq3</value></param>
<param><key>amp</key><value>0.25</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate/20</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>freq2</value></param>
<param><key>amp</key><value>0.8</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate/20</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>freq1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_streams</key><value>12</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_streams</key><value>4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Amplitude DME 2</value></param>
<param><key>size</key><value>Nsamples_Qtime</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ymax</key><value> 1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Amplitude DME1</value></param>
<param><key>size</key><value>Nsamples_Qtime</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ymax</key><value> 1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_1_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_3</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Amplitude ADSB</value></param>
<param><key>size</key><value>Nsamples_Qtime</value></param>
<param><key>srate</key><value>samp_rate/5</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ymax</key><value> 1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>samp_rate</key><value>samp_rate/20*6</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
<param><key>freq</key><value>samp_rate/20*6/3</value></param>
<param><key>amp</key><value>32767</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>0</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>tx_freq</key><value>1e9</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>tx_vga1_gain</key><value>-17</value></param>
<param><key>tx_vga2_gain</key><value>5</value></param>
<param><key>tx_gain3</key><value>-4</value></param>
<param><key>tx_lpf_bandwidth</key><value>6</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>rx_freq</key><value>1e9</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>rx_lna_gain</key><value>3</value></param>
<param><key>rx_vga1_gain</key><value>1</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>18</value></param>
<param><key>rx_lpf_bandwidth</key><value>6</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>2</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>tx_freq</key><value>1200e6</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>tx_vga1_gain</key><value>-17</value></param>
<param><key>tx_vga2_gain</key><value>5</value></param>
<param><key>tx_gain3</key><value>-4</value></param>
<param><key>tx_lpf_bandwidth</key><value>6</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>3</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>rx_freq</key><value>1200e6</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>rx_lna_gain</key><value>3</value></param>
<param><key>rx_vga1_gain</key><value>1</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>+18</value></param>
<param><key>rx_lpf_bandwidth</key><value>6</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_streams</key><value>4</value></param>
</block>
<block>
<key>nutaq_rtdex_sink</key>
<param><key>id</key><value>nutaq_rtdex_sink_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>8</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>8192</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Amplitude DME1</value></param>
<param><key>size</key><value>Nsamples_Qtime*4</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>ymin</key><value>-0.001</value></param>
<param><key>ymax</key><value> 0.001</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_1_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>2**15 -1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_3_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>2**15 -1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_1_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Amplitude DME1</value></param>
<param><key>size</key><value>Nsamples_Qtime</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ymax</key><value> 1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Amplitude DME 2</value></param>
<param><key>size</key><value>Nsamples_Qtime</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ymax</key><value> 1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_streams</key><value>12</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_1_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_3_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_streams</key><value>4</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_1_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_1_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_streams</key><value>4</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Amplitude ADSB</value></param>
<param><key>size</key><value>Nsamples_Qtime</value></param>
<param><key>srate</key><value>samp_rate/5</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ymax</key><value> 1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_00008</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>"dddd"</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate/20</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>gui_hint</key><value>1,1,3,1</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>gui_hint</key><value>2,2,3,2</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>gui_hint</key><value>3,3,3,1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>4</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>1024</value></param>
<param><key>num_chan</key><value>3</value></param>
<param><key>channels</key><value>0,1,2</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>32321.2151515</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate/20</value></param>
<param><key>gui_hint</key><value>1,3,3,1</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate/5</value></param>
<param><key>gui_hint</key><value>3,1,3,1</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>28</value></param>
<param><key>value</key><value>232</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/juan/ets/waveforms/multiplexed_from_rtdex.bin</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_00008_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>"DME1"</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate/20</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_00008_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>"DME2"</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate/20</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_00008_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>"ADSB"</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate/5</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>avio505_adc_three_ch_demux_rtdex</key>
<param><key>id</key><value>avio505_adc_three_ch_demux_rtdex_0</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>8192</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>0</value></param>
<param><key>minoutbuf</key><value>8192</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>adsb_out</key>
<param><key>id</key><value>adsb_out_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Amplitude DME1</value></param>
<param><key>size</key><value>Nsamples_Qtime</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ymin</key><value>-0.001</value></param>
<param><key>ymax</key><value> 0.001</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Amplitude DME1</value></param>
<param><key>size</key><value>Nsamples_Qtime</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ymin</key><value>-0.001</value></param>
<param><key>ymax</key><value> 0.001</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Amplitude ADSB</value></param>
<param><key>size</key><value>Nsamples_Qtime</value></param>
<param><key>srate</key><value>samp_rate/5</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ymax</key><value> 1</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Amplitude DME2</value></param>
<param><key>size</key><value>Nsamples_Qtime</value></param>
<param><key>srate</key><value>samp_rate/20</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ymax</key><value> 1</value></param>
<param><key>tr_level</key><value>1</value></param>
<param><key>tr_chan</key><value>1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>avio505_three_ch_multip_rtdex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>avio505_three_ch_multip_rtdex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1_0</source_block_id><sink_block_id>avio505_three_ch_multip_rtdex_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>avio505_three_ch_multip_rtdex_0</source_block_id><sink_block_id>nutaq_rtdex_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>blocks_short_to_float_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>6</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_1_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_2</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_0_1</source_block_id><sink_block_id>blocks_float_to_complex_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_1_1</source_block_id><sink_block_id>blocks_float_to_complex_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_1</source_block_id><sink_block_id>blocks_float_to_complex_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1</source_block_id><sink_block_id>blocks_short_to_float_0_0_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1</source_block_id><sink_block_id>blocks_short_to_float_0_1_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>8</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>7</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>9</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1</source_block_id><sink_block_id>blocks_short_to_float_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1</source_block_id><sink_block_id>blocks_short_to_float_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_3</source_block_id><sink_block_id>blocks_float_to_complex_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0_0</source_block_id><sink_block_id>avio505_adc_three_ch_demux_rtdex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0_0</source_block_id><sink_block_id>blocks_deinterleave_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_1_1_0</source_block_id><sink_block_id>blocks_float_to_complex_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_2</source_block_id><sink_block_id>blocks_short_to_float_0_0_1_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_2</source_block_id><sink_block_id>blocks_short_to_float_0_3_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_3_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0_0</source_block_id><sink_block_id>blocks_deinterleave_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_1_1</source_block_id><sink_block_id>blocks_float_to_complex_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_3_0</source_block_id><sink_block_id>blocks_float_to_complex_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_interleave_0_1</sink_block_id><source_key>6</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_1_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_2_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_interleave_0_1</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_interleave_0_1</sink_block_id><source_key>8</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_interleave_0_0_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_interleave_0_0_0</sink_block_id><source_key>7</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_interleave_0_0_0</sink_block_id><source_key>9</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_interleave_0_0_0</sink_block_id><source_key>11</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_short_to_float_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_short_to_float_0_0_1_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_short_to_float_0_1_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_short_to_float_0_0_0_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_1_1_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_0_1_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleave_0_1</source_block_id><sink_block_id>blocks_short_to_float_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1_0</source_block_id><sink_block_id>blocks_interleave_0_1</sink_block_id><source_key>10</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_sink_x_0_00008</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0_0_0</source_block_id><sink_block_id>blocks_deinterleave_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0_0_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0_0_0</source_block_id><sink_block_id>blocks_deinterleave_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_1</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_1_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0</source_block_id><sink_block_id>qtgui_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_short_to_float_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>avio505_adc_three_ch_demux_rtdex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>avio505_adc_three_ch_demux_rtdex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_1</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>11</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>avio505_adc_three_ch_demux_rtdex_0</source_block_id><sink_block_id>qtgui_sink_x_0_00008_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>avio505_adc_three_ch_demux_rtdex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_2_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>avio505_adc_three_ch_demux_rtdex_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>avio505_adc_three_ch_demux_rtdex_0</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>avio505_adc_three_ch_demux_rtdex_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>adsb_out_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>adsb_out_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
