<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wifi_loopback</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>0.25e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>out_buf_size</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>ieee802_11_ofdm_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_mac_0</value></param>
<param><key>src_mac</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
<param><key>dst_mac</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
<param><key>bss_mac</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>interval</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>PDU Interval (ms)</value></param>
<param><key>value</key><value>100</value></param>
<param><key>min</key><value>10</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>encoding</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Encoding</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1,2,3,4,5,6,7]</value></param>
<param><key>labels</key><value>["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-0.10</value></param>
<param><key>stop</key><value>0.1</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>interval</value></param>
<param><key>value</key><value>100</value></param>
<param><key>start</key><value>10</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>foo_wireshark_connector</key>
<param><key>id</key><value>foo_wireshark_connector_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>tech</key><value>127</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>wifi_phy_hier</key>
<param><key>id</key><value>wifi_phy_hier_0</value></param>
<param><key>encoding</key><value>encoding</value></param>
<param><key>chan_est</key><value>chan_est</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>10**(noise_var/20.0)</value></param>
<param><key>seed</key><value>6778</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>10**(      (snr+noise_var)   /20.0)</value></param>
</block>
<block>
<key>ieee802_11_ofdm_parse_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_parse_mac_0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>foo_packet_pad2</key>
<param><key>id</key><value>foo_packet_pad2_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>delay</key><value>False</value></param>
<param><key>delay_sec</key><value>0.001</value></param>
<param><key>pad_front</key><value>500</value></param>
<param><key>pad_tail</key><value>0</value></param>
<param><key>minoutbuf</key><value>out_buf_size</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>type</key><value>real</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>options</key><value>[0, 1]</value></param>
<param><key>labels</key><value>["LMS", "Linear Comb"]</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("".join("x" for i in range(pdu_length)))</value></param>
<param><key>period</key><value>interval</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[0, 1]</value></param>
<param><key>labels</key><value>["LMS", "Linear Comb"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-.1</value></param>
<param><key>max</key><value>.1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>snr</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>10</value></param>
<param><key>min</key><value>-15</value></param>
<param><key>max</key><value>30</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>pdu_length</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>500</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1500</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>snr</value></param>
<param><key>value</key><value>36</value></param>
<param><key>start</key><value>-15</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2**15</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>ieee802_11_ofdm_sync_short</key>
<param><key>id</key><value>ieee802_11_ofdm_sync_short_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>threshold</key><value>0.8</value></param>
<param><key>min_plateau</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>encoding</value></param>
<param><key>label</key><value>encoding</value></param>
<param><key>type</key><value>real</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>options</key><value>[0,1,2,3,4,5,6,7]</value></param>
<param><key>labels</key><value>["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/tmp/ofdm.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[ 0.03125000+0.03125j   , -0.08997779+0.00158944j,
       -0.00915291-0.05334709j,  0.09698312-0.00859478j,
        0.06250000+0.j        ,  0.09698312-0.00859478j,
       -0.00915291-0.05334709j, -0.08997779+0.00158944j,
        0.03125000+0.03125j   ,  0.00158944-0.08997779j,
       -0.05334709-0.00915291j, -0.00859478+0.09698312j,
        0.00000000+0.0625j    , -0.00859478+0.09698312j,
       -0.05334709-0.00915291j,  0.00158944-0.08997779j]</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_1</value></param>
</block>
<block>
<key>ofdm_80211_be</key>
<param><key>id</key><value>ofdm_80211_be_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>600</value></param>
</block>
<block>
<key>ieee802_11_moving_average_xx</key>
<param><key>id</key><value>ieee802_11_moving_average_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>length</key><value>640-40</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024*64/4</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>tr_level</key><value>0.23</value></param>
<param><key>label1</key><value>average mio</value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>ofdm_80211_ofdm_sync_short</key>
<param><key>id</key><value>carajito</value></param>
<param><key>log</key><value>False</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>threshold</key><value>0.8</value></param>
<param><key>min_plateau</key><value>2</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024*64/4</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>tr_level</key><value>0.23</value></param>
<param><key>label1</key><value>OUTput SQR</value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pdu_length</value></param>
<param><key>value</key><value>500</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1500</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_var</value></param>
<param><key>value</key><value>-150</value></param>
<param><key>start</key><value>-180</value></param>
<param><key>stop</key><value>-40</value></param>
<param><key>step</key><value>5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>SUBSTRACTED</value></param>
<param><key>size</key><value>1024*64/4</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>tr_level</key><value>0.23</value></param>
<param><key>label1</key><value>short_match_filter</value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>ofdm_80211_short_match_filter</key>
<param><key>id</key><value>marica</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>ymin</key><value>-0.05</value></param>
<param><key>gui_hint</key><value>2,1,2,1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>tr_level</key><value>0.3</value></param>
<param><key>tr_delay</key><value>2e-3</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024*2</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>tr_level</key><value>1.5e-9</value></param>
<param><key>label1</key><value>(1) MA mio</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value>(2) MA afuera</value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>270</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>1270</value></param>
</block>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>ieee802_11_ofdm_parse_mac_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>ieee802_11_ofdm_mac_0</sink_block_id><source_key>strobe</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>foo_packet_pad2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_mac_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>phy out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_parse_mac_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>fer</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>foo_packet_pad2_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>marica</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>ieee802_11_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marica</source_block_id><sink_block_id>ofdm_80211_be_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_80211_be_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_1</source_block_id><sink_block_id>ieee802_11_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>carajito</source_block_id><sink_block_id>blocks_null_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marica</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_1</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marica</source_block_id><sink_block_id>blocks_delay_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>carajito</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>carajito</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_moving_average_xx_0_0</source_block_id><sink_block_id>blocks_delay_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_0</source_block_id><sink_block_id>carajito</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_null_sink_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marica</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marica</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
