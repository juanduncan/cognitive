<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>perseus_adac250</value></param>
<param><key>title</key><value>Perseus ADAC250 Streaming</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_size_eth</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>adac250_freq</value></param>
<param><key>value</key><value>250e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>adac250_freq/interp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp_rate</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_size_pcie</value></param>
<param><key>value</key><value>8192*6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_size</value></param>
<param><key>value</key><value>packet_size_gige</value></param>
</block>
<block>
<key>nutaq_carrier_perseus</key>
<param><key>id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>ip_addr</key><value>192.168.0.101</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq1</value></param>
<param><key>label</key><value>DDS 1</value></param>
<param><key>value</key><value>500e3</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,1,1,2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_dac_a</value></param>
<param><key>label</key><value>Gain DAC A (dB)</value></param>
<param><key>value</key><value>24</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>24</value></param>
<param><key>step</key><value>1</value></param>
<param><key>widget</key><value>knob</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_dac_b</value></param>
<param><key>label</key><value>Gain DAC B (dB)</value></param>
<param><key>value</key><value>24</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>24</value></param>
<param><key>step</key><value>1</value></param>
<param><key>widget</key><value>knob</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>4,3,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_adc_a</value></param>
<param><key>label</key><value>Gain ADC A (dB)</value></param>
<param><key>value</key><value>6</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>6</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>widget</key><value>knob</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>4,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_adc_b</value></param>
<param><key>label</key><value>Gain ADC B (dB)</value></param>
<param><key>value</key><value>6</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>6</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>widget</key><value>knob</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>4,4,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq2</value></param>
<param><key>label</key><value>DDS 2</value></param>
<param><key>value</key><value>500e3</value></param>
<param><key>start</key><value>-samp_rate/2</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,3,1,2</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0_0</value></param>
<param><key>scale</key><value>2**15-1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>freq2</value></param>
<param><key>amp</key><value>0.95</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>freq1</value></param>
<param><key>amp</key><value>0.95</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>scale</key><value>2**15-1</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0</value></param>
<param><key>scale</key><value>2**15-1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>2**15-1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>3,1,1,4</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>minoutbuf</key><value>packet_size*2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>2,1,1,4</value></param>
</block>
<block>
<key>nutaq_adac250</key>
<param><key>id</key><value>ADAC250_config</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>0</value></param>
<param><key>ref_source</key><value>0</value></param>
<param><key>ref_clk_freq</key><value>10e6</value></param>
<param><key>adc_clk_freq</key><value>adac250_freq</value></param>
<param><key>dac_clk_freq</key><value>adac250_freq</value></param>
<param><key>dac_interp</key><value>1</value></param>
<param><key>adc_a_gain</key><value>gain_adc_a</value></param>
<param><key>adc_b_gain</key><value>gain_adc_b</value></param>
<param><key>dac_a_gain</key><value>gain_dac_a</value></param>
<param><key>dac_b_gain</key><value>gain_dac_b</value></param>
<param><key>ref_clk_tuning</key><value>32768</value></param>
</block>
<block>
<key>nutaq_rtdex_sink</key>
<param><key>id</key><value>nutaq_rtdex_sink_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>packet_size</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>1</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>2</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>packet_size</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>1</value></param>
<param><key>minoutbuf</key><value>packet_size*2</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>DacMuxSel</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>3</value></param>
<param><key>index</key><value>0</value></param>
<param><key>value</key><value>3</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>RtdexEnDelay</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>4</value></param>
<param><key>index</key><value>5</value></param>
<param><key>value</key><value>int(adac250_freq)</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>RtdexEn</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>5</value></param>
<param><key>index</key><value>6</value></param>
<param><key>value</key><value>0</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>RtdexRxEn</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>6</value></param>
<param><key>index</key><value>7</value></param>
<param><key>value</key><value>0</value></param>
<param><key>update_rate</key><value>10</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>RtdexRxEn</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>RtdexEn</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_short_to_float_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_float_to_short_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_short_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>nutaq_rtdex_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
