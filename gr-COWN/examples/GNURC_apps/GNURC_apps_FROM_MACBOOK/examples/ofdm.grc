<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ofdm</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_size_gige</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_size_pcie</value></param>
<param><key>value</key><value>8192*6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>76.8e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_size</value></param>
<param><key>value</key><value>packet_size_gige</value></param>
</block>
<block>
<key>nutaq_carrier_perseus</key>
<param><key>id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>ip_addr</key><value>192.168.0.101</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0_0</value></param>
<param><key>scale</key><value>2**15-1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>samples_per_second</key><value>7e6</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>2**15-1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>4096*10</value></param>
<param><key>ymin</key><value>-4e3</value></param>
<param><key>ymax</key><value>4e3</value></param>
<param><key>xmin</key><value>-4e3</value></param>
<param><key>xmax</key><value>4e3</value></param>
</block>
<block>
<key>nutaq_rtdex_sink</key>
<param><key>id</key><value>nutaq_rtdex_sink_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>30</value></param>
<param><key>type</key><value>int</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>packet_size</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>0</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>LOOPBACK_OPTION</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>12</value></param>
<param><key>index</key><value>14</value></param>
<param><key>value</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>31</value></param>
<param><key>type</key><value>int</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>packet_size</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>0</value></param>
<param><key>minoutbuf</key><value>packet_size*2</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>32</value></param>
<param><key>type</key><value>int</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>packet_size</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>1</value></param>
<param><key>minoutbuf</key><value>packet_size*2</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/opt/Nutaq/ADP6/ADP_MicroTCA/sdk/media/wildlife.mpg</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0_0_0_0_0_0_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>11</value></param>
<param><key>index</key><value>13</value></param>
<param><key>value</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>10</value></param>
<param><key>index</key><value>6</value></param>
<param><key>value</key><value>1</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>9</value></param>
<param><key>index</key><value>4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>8</value></param>
<param><key>index</key><value>3</value></param>
<param><key>value</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>6</value></param>
<param><key>index</key><value>1</value></param>
<param><key>value</key><value>100000</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>index</key><value>0</value></param>
<param><key>value</key><value>1</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>17</value></param>
<param><key>index</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>16</value></param>
<param><key>index</key><value>0</value></param>
<param><key>value</key><value>1</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_1</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>15</value></param>
<param><key>index</key><value>21</value></param>
<param><key>value</key><value>10</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>14</value></param>
<param><key>index</key><value>16</value></param>
<param><key>value</key><value>120</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0_0_0_0_0_0_0_0_0_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>13</value></param>
<param><key>index</key><value>15</value></param>
<param><key>value</key><value>1</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>2</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>tx_freq</key><value>453e6</value></param>
<param><key>datarate</key><value>samp_rate</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>tx_vga1_gain</key><value>-7</value></param>
<param><key>tx_vga2_gain</key><value>10</value></param>
<param><key>tx_gain3</key><value>10</value></param>
<param><key>tx_lpf_bandwidth</key><value>1</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>3</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>rx_freq</key><value>453e6</value></param>
<param><key>datarate</key><value>samp_rate</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>rx_lna_gain</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>2</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>5</value></param>
<param><key>rx_lpf_bandwidth</key><value>1</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>rx_gain_ctrl</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>5</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>rx_freq</key><value>453e6</value></param>
<param><key>datarate</key><value>samp_rate</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>rx_lna_gain</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>2</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>5</value></param>
<param><key>rx_lpf_bandwidth</key><value>1</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>rx_gain_ctrl</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>ipaddr</key><value>192.168.0.100</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>4</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>tx_freq</key><value>453e6</value></param>
<param><key>datarate</key><value>samp_rate</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>tx_vga1_gain</key><value>-7</value></param>
<param><key>tx_vga2_gain</key><value>10</value></param>
<param><key>tx_gain3</key><value>10</value></param>
<param><key>tx_lpf_bandwidth</key><value>1</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>1</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_int_to_float_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>nutaq_rtdex_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
