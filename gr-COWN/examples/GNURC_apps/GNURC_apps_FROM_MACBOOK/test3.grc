<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>veausted</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>freq</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>1e3</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ampl</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>amp</key><value>ampl</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>minsize</key><value>10</value></param>
<param><key>maxsize</key><value>10</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>pyqt_time_plot_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>l</key><value>tubella</value></param>
</block>
<block>
<key>spectsensing_time_plot</key>
<param><key>id</key><value>spectsensing_time_plot_0</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>spectsensing_test_plot</key>
<param><key>id</key><value>spectsensing_test_plot_0</value></param>
</block>
<block>
<key>spectsensing_time_plot</key>
<param><key>id</key><value>spectsensing_time_plot_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>spectsensing_test_plot_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_test_plot_0</source_block_id><sink_block_id>spectsensing_time_plot_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>spectsensing_test_plot_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_test_plot_0</source_block_id><sink_block_id>spectsensing_time_plot_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
