<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>communication_ramp_seq2</value></param>
<param><key>title</key><value>Communication ramp sequence</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>update_rate</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>14.4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_rate</value></param>
<param><key>value</key><value>44.1e3</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/juan/Desktop/recorded_sequence.bin</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>rx_freq</key><value>943e6</value></param>
<param><key>datarate</key><value>data_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>rx_lna_gain</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>1</value></param>
<param><key>rx_gain2</key><value>16</value></param>
<param><key>rx_gain3</key><value>5</value></param>
<param><key>rx_lpf_bandwidth</key><value>2</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>data_rate</value></param>
<param><key>ignoretag</key><value>False</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>digital_scrambler_bb</key>
<param><key>id</key><value>digital_scrambler_bb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>mask</key><value>0x8A</value></param>
<param><key>seed</key><value>0x7F</value></param>
<param><key>len</key><value>7</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>digital_dxpsk_mod</key>
<param><key>id</key><value>digital_dxpsk_mod_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>dqpsk</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>digital_descrambler_bb</key>
<param><key>id</key><value>digital_descrambler_bb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>mask</key><value>0x8A</value></param>
<param><key>seed</key><value>0x7F</value></param>
<param><key>len</key><value>7</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>data_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>25</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>300,200</value></param>
<param><key>grid_pos</key><value>(1,1,1,1)</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>128</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>2047</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0</value></param>
<param><key>scale</key><value>2047</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>scale</key><value>2**11 -1</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>1e3</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
<param><key>freq</key><value>0*data_rate/(samp_per_sym*4)/200</value></param>
<param><key>amp</key><value>0.9</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>data_rate/820</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>data_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>1e6</value></param>
<param><key>amp</key><value>0.9</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>data_rate</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>win_size</key><value>10,10</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>source_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>win_size</key><value>(400,100 )</value></param>
<param><key>grid_pos</key><value>(1,1,1,1)</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>bits_per_symbol</key><value>2</value></param>
<param><key>preamble</key><value></value></param>
<param><key>access_code</key><value></value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>128*4</value></param>
</block>
<block>
<key>digital_dxpsk_mod</key>
<param><key>id</key><value>digital_dxpsk_mod_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>dqpsk</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>bt</key><value>0.35</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>variable_slider_0</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>source_rate</value></param>
<param><key>waveform</key><value>analog.GR_TRI_WAVE</value></param>
<param><key>freq</key><value>source_rate/10000</value></param>
<param><key>amp</key><value>variable_slider_0</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>1200</value></param>
<param><key>num_chan</key><value>2</value></param>
<param><key>channels</key><value>1,3</value></param>
</block>
<block>
<key>nutaq_carrier_perseus</key>
<param><key>id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>ip_addr</key><value>192.168.0.102</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>scale</key><value>2**11 -1</value></param>
</block>
<block>
<key>digital_dxpsk_demod</key>
<param><key>id</key><value>digital_dxpsk_demod_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>dqpsk</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sync_out</key><value>False</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>freq_error</key><value>0.0</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>access_code</key><value></value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>3</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>8192</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>4</value></param>
</block>
<block>
<key>nutaq_rtdex_sink</key>
<param><key>id</key><value>nutaq_rtdex_sink_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>8192</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>rx_freq</key><value>943e6</value></param>
<param><key>datarate</key><value>data_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>rx_lna_gain</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>1</value></param>
<param><key>rx_gain2</key><value>16</value></param>
<param><key>rx_gain3</key><value>5</value></param>
<param><key>rx_lpf_bandwidth</key><value>11</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>digital_dxpsk_demod</key>
<param><key>id</key><value>digital_dxpsk_demod_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>dqpsk</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sync_out</key><value>False</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>data_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>win_size</key><value>300,200</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>data_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>True</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>win_size</key><value>(300,200)</value></param>
<param><key>grid_pos</key><value>(1,2,1,1)</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_constellationsink2</key>
<param><key>id</key><value>wxgui_constellationsink2_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>title</key><value>Constellation Plot</value></param>
<param><key>samp_rate</key><value>data_rate</value></param>
<param><key>frame_rate</key><value>10</value></param>
<param><key>const_size</key><value>2048/4</value></param>
<param><key>M</key><value>4</value></param>
<param><key>theta</key><value>0</value></param>
<param><key>loop_bw</key><value>5/100.0</value></param>
<param><key>fmax</key><value>0.06</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>0.005</value></param>
<param><key>symbol_rate</key><value>data_rate/samp_per_sym</value></param>
<param><key>omega_limit</key><value>0.005</value></param>
<param><key>win_size</key><value>300,300</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>data_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>25</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>300,200</value></param>
<param><key>grid_pos</key><value>(1,1,1,1)</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>0</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>tx_freq</key><value>0.943e9</value></param>
<param><key>datarate</key><value>data_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1e9</value></param>
<param><key>tx_vga1_gain</key><value>-10</value></param>
<param><key>tx_vga2_gain</key><value>15</value></param>
<param><key>tx_gain3</key><value>3</value></param>
<param><key>tx_lpf_bandwidth</key><value>11</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>2</value></param>
<param><key>index</key><value>1</value></param>
<param><key>value</key><value>3</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1.0737e8*0</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>5</value></param>
<param><key>index</key><value>4</value></param>
<param><key>value</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>6</value></param>
<param><key>index</key><value>3</value></param>
<param><key>value</key><value>7</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>4</value></param>
<param><key>index</key><value>2</value></param>
<param><key>value</key><value>00000</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-1.0737e8*0</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>4</value></param>
<param><key>index</key><value>0</value></param>
<param><key>value</key><value>000000</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>4</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>4</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_0</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>tx_freq</key><value>943e6</value></param>
<param><key>datarate</key><value>data_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>1</value></param>
<param><key>update_rate</key><value>1e9</value></param>
<param><key>tx_vga1_gain</key><value>-10</value></param>
<param><key>tx_vga2_gain</key><value>15</value></param>
<param><key>tx_gain3</key><value>3</value></param>
<param><key>tx_lpf_bandwidth</key><value>6</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_short_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>nutaq_rtdex_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_dxpsk_demod_0</source_block_id><sink_block_id>digital_descrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_descrambler_bb_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0_0</source_block_id><sink_block_id>digital_dxpsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_scrambler_bb_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_dxpsk_mod_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>digital_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_dxpsk_mod_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>blks2_packet_decoder_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_short_to_float_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>digital_dxpsk_demod_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_dxpsk_demod_0_0</source_block_id><sink_block_id>blks2_packet_decoder_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>digital_dxpsk_mod_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_1</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>wxgui_constellationsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_1</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_float_to_int_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_0_0</source_block_id><sink_block_id>nutaq_custom_register_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_0</source_block_id><sink_block_id>nutaq_custom_register_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_int_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
