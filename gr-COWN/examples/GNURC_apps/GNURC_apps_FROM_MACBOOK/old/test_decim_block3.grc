<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_decim_block3</value></param>
<param><key>title</key><value>Test for Custom Decimator block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfft</value></param>
<param><key>value</key><value>2**15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>16e3/2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>archivoaborrar</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>decimation</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>data_rate/decimation</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>win_size</key><value>300,100</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>taps</key><value>1, 0.1, 0.001</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>data_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>200</value></param>
<param><key>amp</key><value>0.4955</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>data_rate</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>data_rate</value></param>
<param><key>waveform</key><value>analog.GR_SAW_WAVE</value></param>
<param><key>freq</key><value>200</value></param>
<param><key>amp</key><value>2.4955</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>data_rate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
<param><key>freq</key><value>400</value></param>
<param><key>amp</key><value>2.4955</value></param>
<param><key>offset</key><value>4</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>0.1</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>data_rate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>data_rate</value></param>
</block>
<block>
<key>baz_delay</key>
<param><key>id</key><value>baz_delay_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>delay</key><value>27</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>spectsensing_compute_statistics</key>
<param><key>id</key><value>spectsensing_compute_statistics_0</value></param>
<param><key>nfft</key><value>nfft</value></param>
<param><key>fs</key><value>data_rate</value></param>
<param><key>sens_time</key><value>0.0065*1000</value></param>
<param><key>pfe</key><value>0.01</value></param>
<param><key>pfs</key><value>0.01</value></param>
<param><key>num_items</key><value>40</value></param>
<param><key>L</key><value>54</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>decimation</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>baz_plot_sink</key>
<param><key>id</key><value>baz_plot_sink_1_0</value></param>
<param><key>title</key><value>Plot</value></param>
<param><key>samp_rate</key><value>data_rate/decimation</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>60</value></param>
<param><key>data_len</key><value>decimation</value></param>
<param><key>win_size</key><value>300, 200</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
</block>
<block>
<key>baz_plot_sink</key>
<param><key>id</key><value>baz_plot_sink_1</value></param>
<param><key>title</key><value>Plot</value></param>
<param><key>samp_rate</key><value>data_rate/decimation</value></param>
<param><key>y_per_div</key><value>2</value></param>
<param><key>y_divs</key><value>4</value></param>
<param><key>ref_level</key><value>4</value></param>
<param><key>data_len</key><value>decimation</value></param>
<param><key>win_size</key><value>300, 200</value></param>
<param><key>grid_pos</key><value>1,5,1,1</value></param>
</block>
<block>
<key>baz_plot_sink</key>
<param><key>id</key><value>baz_plot_sink_1_0_0_0</value></param>
<param><key>title</key><value>Plot</value></param>
<param><key>samp_rate</key><value>data_rate/decimation</value></param>
<param><key>y_per_div</key><value>1</value></param>
<param><key>y_divs</key><value>2</value></param>
<param><key>ref_level</key><value>1</value></param>
<param><key>data_len</key><value>decimation</value></param>
<param><key>win_size</key><value>300, 200</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
</block>
<block>
<key>baz_plot_sink</key>
<param><key>id</key><value>baz_plot_sink_1_0_0_0_0</value></param>
<param><key>title</key><value>Plot</value></param>
<param><key>samp_rate</key><value>data_rate/decimation</value></param>
<param><key>y_per_div</key><value>1</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>10</value></param>
<param><key>data_len</key><value>decimation</value></param>
<param><key>win_size</key><value>300, 200</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
</block>
<block>
<key>baz_plot_sink</key>
<param><key>id</key><value>baz_plot_sink_1_0_0</value></param>
<param><key>title</key><value>Plot</value></param>
<param><key>samp_rate</key><value>data_rate/decimation</value></param>
<param><key>y_per_div</key><value>1</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>5</value></param>
<param><key>data_len</key><value>decimation</value></param>
<param><key>win_size</key><value>300, 200</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
</block>
<block>
<key>DataConversion_eaver_resynchronizer</key>
<param><key>id</key><value>DataConversion_eaver_resynchronizer_0</value></param>
<param><key>num_items</key><value>decimation</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>baz_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>baz_delay_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>DataConversion_eaver_resynchronizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0_0</source_block_id><sink_block_id>DataConversion_eaver_resynchronizer_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>baz_plot_sink_1_0_0_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DataConversion_eaver_resynchronizer_0</source_block_id><sink_block_id>spectsensing_compute_statistics_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>baz_plot_sink_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>baz_plot_sink_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>baz_plot_sink_1_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>baz_plot_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DataConversion_eaver_resynchronizer_0</source_block_id><sink_block_id>spectsensing_compute_statistics_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
