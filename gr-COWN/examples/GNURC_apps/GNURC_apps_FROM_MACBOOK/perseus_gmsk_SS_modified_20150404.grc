<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>perseus_s_sensing</value></param>
<param><key>title</key><value>Perseus Spectrum Sensing</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversampling</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RF_freq</value></param>
<param><key>value</key><value>943e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_size</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfft</value></param>
<param><key>value</key><value>2**15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>value</key><value>0.125</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PSD_averaging</value></param>
<param><key>value</key><value>600</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>5</value></param>
<param><key>index</key><value>4</value></param>
<param><key>value</key><value>1</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>4</value></param>
<param><key>index</key><value>1</value></param>
<param><key>value</key><value>3</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>8</value></param>
<param><key>index</key><value>3</value></param>
<param><key>value</key><value>7</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>2</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>rx_freq</key><value>RF_freq</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>rx_lna_gain</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>2</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>-8</value></param>
<param><key>rx_lpf_bandwidth</key><value>2</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>nutaq_radio420_rx</key>
<param><key>id</key><value>nutaq_radio420_rx_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>3</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>rx_freq</key><value>RF_freq</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>rx_lna_gain</key><value>2</value></param>
<param><key>rx_vga1_gain</key><value>2</value></param>
<param><key>rx_gain2</key><value>0</value></param>
<param><key>rx_gain3</key><value>-8</value></param>
<param><key>rx_lpf_bandwidth</key><value>2</value></param>
<param><key>rx_rf_filter</key><value>2</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>rx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>DataConversion_reint_short_float</key>
<param><key>id</key><value>DataConversion_reint_short_float_0</value></param>
</block>
<block>
<key>DataConversion_reint_short_float</key>
<param><key>id</key><value>DataConversion_reint_short_float_0_1</value></param>
</block>
<block>
<key>DataConversion_reint_short_float</key>
<param><key>id</key><value>DataConversion_reint_short_float_0_2</value></param>
</block>
<block>
<key>DataConversion_reint_short_float</key>
<param><key>id</key><value>DataConversion_reint_short_float_0_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>2.0**(16*1)</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>2.0**(16*2)</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>2.0**(16*0)</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>(samp_rate/819)/40</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>win_size</key><value>500,5</value></param>
<param><key>grid_pos</key><value>4,3,2,1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_STRIPCHART</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1/samp_rate*(2**32)</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0_0_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate/40</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>400,100</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_constellationsink2</key>
<param><key>id</key><value>wxgui_constellationsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>title</key><value>Constellation Plot</value></param>
<param><key>samp_rate</key><value>samp_rate/40</value></param>
<param><key>frame_rate</key><value>2</value></param>
<param><key>const_size</key><value>2048</value></param>
<param><key>M</key><value>4</value></param>
<param><key>theta</key><value>0</value></param>
<param><key>loop_bw</key><value>6.28/100.0</value></param>
<param><key>fmax</key><value>0.06</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>0.005</value></param>
<param><key>symbol_rate</key><value>samp_rate/40/4</value></param>
<param><key>omega_limit</key><value>0.005</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>amplitude</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_streams</key><value>4</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>(samp_rate/819)/40</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>win_size</key><value>500,5</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_STRIPCHART</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0_0</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0_0</value></param>
<param><key>scale</key><value>2**11-1</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_S_S</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>3</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>1200</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>3</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>index</key><value>2</value></param>
<param><key>value</key><value>int(0/samp_rate*(2**32))</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>nutaq_carrier_perseus</key>
<param><key>id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>ip_addr</key><value>192.168.0.101</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/juan/GNURC_apps/byte2.bin</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate/40</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>400,100</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_1_0</value></param>
<param><key>scale</key><value>2**11</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_0_0</value></param>
<param><key>scale</key><value>2**11</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate/40</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>True</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>win_size</key><value>400,100</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_NORM</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>bits_per_symbol</key><value>8</value></param>
<param><key>preamble</key><value></value></param>
<param><key>access_code</key><value></value></param>
<param><key>pad_for_usrp</key><value>True</value></param>
<param><key>payload_length</key><value>128</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/juan/Music/de_mi.mp3</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>samples_per_symbol</key><value>oversampling</value></param>
<param><key>bt</key><value>0.71</value></param>
</block>
<block>
<key>nutaq_rtdex_sink</key>
<param><key>id</key><value>nutaq_rtdex_sink_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>packet_size</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>0</value></param>
<param><key>selected_card</key><value>1</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>0</value></param>
<param><key>tx_freq</key><value>RF_freq</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>tx_vga1_gain</key><value>-10</value></param>
<param><key>tx_vga2_gain</key><value>15</value></param>
<param><key>tx_gain3</key><value>3</value></param>
<param><key>tx_lpf_bandwidth</key><value>2</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>freq_offset</value></param>
<param><key>value</key><value>variable_funcion</value></param>
<param><key>min</key><value>-1e7</value></param>
<param><key>max</key><value>1e7</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>label</key><value>freq_offset</value></param>
<param><key>value</key><value>variable_funcion</value></param>
<param><key>start</key><value>-1e7</value></param>
<param><key>stop</key><value>1e7</value></param>
<param><key>step</key><value>1e4</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>2</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>n</key><value>3</value></param>
<param><key>k</key><value>-24</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>(samp_rate/819/4)</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>5</value></param>
<param><key>win_size</key><value>600,601</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_NORM</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1/1e6</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>2*4e3 + 0*samp_rate/40/(oversampling*8*2)</value></param>
</block>
<block>
<key>nutaq_radio420_tx</key>
<param><key>id</key><value>nutaq_radio420_tx_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>1</value></param>
<param><key>selected_card</key><value>2</value></param>
<param><key>enable</key><value>1</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>tx_freq</key><value>RF_freq</value></param>
<param><key>datarate</key><value>samp_rate*2</value></param>
<param><key>calibrate</key><value>0</value></param>
<param><key>band</key><value>0</value></param>
<param><key>update_rate</key><value>1</value></param>
<param><key>tx_vga1_gain</key><value>-10</value></param>
<param><key>tx_vga2_gain</key><value>15</value></param>
<param><key>tx_gain3</key><value>3</value></param>
<param><key>tx_lpf_bandwidth</key><value>2</value></param>
<param><key>ref_clk_ctrl</key><value>0</value></param>
<param><key>rf_ctrl</key><value>0</value></param>
<param><key>tx_gain_ctrl</key><value>0</value></param>
<param><key>pll_cpld_ctrl</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>40</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_0_0_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>7</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>packet_size</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>2</value></param>
<param><key>minoutbuf</key><value>packet_size*2</value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>36</value></param>
<param><key>index</key><value>0</value></param>
<param><key>value</key><value>int((variable_funcion)/samp_rate*(2**32))</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>DataConversion_eaver_resynchronizer</key>
<param><key>id</key><value>DataConversion_eaver_resynchronizer_0</value></param>
<param><key>num_items</key><value>decimation</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>40</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>40</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>40</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>40</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>spectsensing_subband_selector</key>
<param><key>id</key><value>spectsensing_subband_selector_0</value></param>
<param><key>num_items</key><value>40</value></param>
<param><key>label</key><value>Selection</value></param>
<param><key>value</key><value>0</value></param>
<param><key>fs</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/juan/Desktop/file_xs_for_cal.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>40</value></param>
</block>
<block>
<key>spectsensing_ss_subband_plot</key>
<param><key>id</key><value>spectsensing_ss_subband_plot_0_0</value></param>
<param><key>show_TS</key><value>show_test_statistics</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>spectsensing_xs_plot</key>
<param><key>id</key><value>spectsensing_xs_plot_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>ENABLE_TX1_variable_check_box</value></param>
<param><key>label</key><value>Enable Transmission</value></param>
<param><key>type</key><value>int</value></param>
<param><key>value</key><value>True</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>2.0**(16*1)</value></param>
</block>
<block>
<key>DataConversion_reint_short_float</key>
<param><key>id</key><value>DataConversion_reint_short_float_0_3</value></param>
</block>
<block>
<key>DataConversion_reint_short_float</key>
<param><key>id</key><value>DataConversion_reint_short_float_0_2_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>2.0**(16*2)</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>2.0**(16*0)</value></param>
</block>
<block>
<key>DataConversion_reint_short_float</key>
<param><key>id</key><value>DataConversion_reint_short_float_0_1_0</value></param>
</block>
<block>
<key>nutaq_rtdex_source</key>
<param><key>id</key><value>nutaq_rtdex_source_S_S_0</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>media_type</key><value>0</value></param>
<param><key>packet_size</key><value>1300</value></param>
<param><key>num_chan</key><value>1</value></param>
<param><key>channels</key><value>0</value></param>
</block>
<block>
<key>DataConversion_reint_short_float</key>
<param><key>id</key><value>DataConversion_reint_short_float_0_0_0</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0_0_1</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_streams</key><value>4</value></param>
</block>
<block>
<key>DataConversion_eaver_resynchronizer</key>
<param><key>id</key><value>DataConversion_eaver_resynchronizer_0_0</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>spectsensing_ss_pds_plot</key>
<param><key>id</key><value>spectsensing_ss_pds_plot_0</value></param>
<param><key>nfft</key><value>nfft</value></param>
<param><key>fs</key><value>samp_rate</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>spectsensing_compute_statistics</key>
<param><key>id</key><value>spectsensing_compute_statistics_0</value></param>
<param><key>nfft</key><value>nfft</value></param>
<param><key>fs</key><value>samp_rate</value></param>
<param><key>sens_time</key><value>0.0065</value></param>
<param><key>pfe</key><value>1e-9</value></param>
<param><key>pfs</key><value>1e-9</value></param>
<param><key>num_items</key><value>40</value></param>
<param><key>L</key><value>54</value></param>
</block>
<block>
<key>spectsensing_xs_plot</key>
<param><key>id</key><value>spectsensing_xs_plot_1</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>spectsensing_ss_edge_plot</key>
<param><key>id</key><value>spectsensing_ss_edge_plot_0</value></param>
<param><key>show_TS</key><value>show_test_statistics</value></param>
<param><key>l</key><value> </value></param>
</block>
<block>
<key>nutaq_custom_register</key>
<param><key>id</key><value>nutaq_custom_register_0_1_1</value></param>
<param><key>target_id</key><value>nutaq_carrier_perseus_TX</value></param>
<param><key>block_priority</key><value>9</value></param>
<param><key>index</key><value>6</value></param>
<param><key>value</key><value>PSD_averaging</value></param>
<param><key>update_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_funcion</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>0.1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>ipaddr</key><value>192.168.0.100</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>show_test_statistics</value></param>
<param><key>label</key><value>Show Test Statistics (ReL and Rs)</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>samples_per_symbol</key><value>oversampling</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>freq_error</key><value>0.0</value></param>
</block>
<block>
<key>blks2_packet_decoder</key>
<param><key>id</key><value>blks2_packet_decoder_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>access_code</key><value></value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1020*64</value></param>
<param><key>srate</key><value>samp_rate/40</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>wxgui_scopesink2_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_S_S</source_block_id><sink_block_id>blocks_deinterleave_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0</source_block_id><sink_block_id>DataConversion_reint_short_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0</source_block_id><sink_block_id>DataConversion_reint_short_float_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0</source_block_id><sink_block_id>DataConversion_reint_short_float_0_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0</source_block_id><sink_block_id>DataConversion_reint_short_float_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DataConversion_reint_short_float_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DataConversion_reint_short_float_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DataConversion_reint_short_float_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>DataConversion_eaver_resynchronizer_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>DataConversion_reint_short_float_0</source_block_id><sink_block_id>DataConversion_eaver_resynchronizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DataConversion_eaver_resynchronizer_0</source_block_id><sink_block_id>spectsensing_compute_statistics_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>DataConversion_eaver_resynchronizer_0</source_block_id><sink_block_id>spectsensing_compute_statistics_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0</source_block_id><sink_block_id>wxgui_constellationsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_0_0_0</source_block_id><sink_block_id>blocks_deinterleave_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>blks2_packet_decoder_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_1</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_1</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>nutaq_rtdex_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_2</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_short_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_short_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_packet_decoder_1</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_1_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_1</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>blocks_null_sink_1_3</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>blocks_null_sink_1_2</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>blocks_null_sink_1_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>spectsensing_xs_plot_0</sink_block_id><source_key>spec_sens_pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>spectsensing_ss_edge_plot_0</sink_block_id><source_key>spec_sens_pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>spectsensing_ss_subband_plot_0_0</sink_block_id><source_key>spec_sens_pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>spectsensing_subband_selector_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>spectsensing_subband_selector_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>spectsensing_compute_statistics_0</source_block_id><sink_block_id>spectsensing_subband_selector_0</sink_block_id><source_key>3</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>spectsensing_subband_selector_0</source_block_id><sink_block_id>probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>DataConversion_eaver_resynchronizer_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>DataConversion_eaver_resynchronizer_0_0</source_block_id><sink_block_id>spectsensing_ss_pds_plot_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DataConversion_eaver_resynchronizer_0_0</source_block_id><sink_block_id>spectsensing_ss_pds_plot_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>spectsensing_ss_pds_plot_0</source_block_id><sink_block_id>spectsensing_xs_plot_1</sink_block_id><source_key>psd_pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>DataConversion_reint_short_float_0_3</source_block_id><sink_block_id>DataConversion_eaver_resynchronizer_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DataConversion_reint_short_float_0_2_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DataConversion_reint_short_float_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DataConversion_reint_short_float_0_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nutaq_rtdex_source_S_S_0</source_block_id><sink_block_id>blocks_deinterleave_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0_1</source_block_id><sink_block_id>DataConversion_reint_short_float_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0_1</source_block_id><sink_block_id>DataConversion_reint_short_float_0_2_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0_1</source_block_id><sink_block_id>DataConversion_reint_short_float_0_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0_1</source_block_id><sink_block_id>DataConversion_reint_short_float_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_1</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_3</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
